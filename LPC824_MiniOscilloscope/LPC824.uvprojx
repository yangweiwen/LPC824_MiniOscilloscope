# Keil uVision project LPC824.uvprojx, settings and files
target LPC824 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: NXP.LPC824_DFP.12.1.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LPC824_MiniOscilloscope +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS
  c include: .\Common;.\Drivers;.\Common\board;.\Common\chip;.\Common\CMSIS;.\Common\startup;.\OLED;.\Drivers\OLED;.\Drivers\delay;.\Application;.\Drivers\adc;.\FFT;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.7.0\CMSIS\Core\Include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.7.0\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group App
    ./Application/: main.c
  group Includes
    ./Drivers/acmp/: acmp_8xx.h
    ./Drivers/adc/: adc_8xx.h
    ./Drivers/crc/: crc_8xx.h
    ./Drivers/dma/: dma_8xx.h
    ./Drivers/gpio/: gpio_8xx.h
    ./Drivers/i2c/: i2c_8xx.h
    ./Drivers/iap/: iap.h
    ./Drivers/IIC/: IIC.h
    ./Drivers/inmux/: inmux_8xx.h
    ./Drivers/mrt/: mrt_8xx.h stopwatch.h
    ./Drivers/pinint/: pinint_8xx.h
    ./Drivers/pmu/: pmu_8xx.h
    ./Drivers/rom/: rom_i2c_8xx.h rom_pwr_8xx.h rom_uart_8xx.h romapi_8xx.h
    ./Drivers/sctimer/: sct_8xx.h sct_pwm_8xx.h
    ./Drivers/spi/: spi_8xx.h
    ./Drivers/uart/: ring_buffer.h uart_8xx.h
    ./Drivers/wkt/: wkt_8xx.h
    ./Drivers/wwdt/: wwdt_8xx.h
  group Common
    ./Common/startup/: keil_startup_lpc82x.s
    ./Common/board/: board.c
    ./Common/chip/: sysinit_8xx.c syscon_8xx.c clock_8xx.c ioswm_8xx.c
  group Drivers
    ./Drivers/IIC/: IIC.c
    ./Drivers/gpio/: gpio_8xx.c
    ./Drivers/uart/: ring_buffer.c uart_8xx.c
    ./Drivers/delay/: delay.c
    ./Application/: ADC.C key_PINT.c key_PINT.h
    ./Drivers/adc/: adc_8xx.c
    ./Drivers/dma/: dma_8xx.c
    ./Drivers/pinint/: pinint_8xx.c
  group OLED
    ./Drivers/OLED/: oled.c oledfont.h oled.h bmp.h
  group FFT
    ./FFT/: arm_common_tables.c fftutil.c fftwindows.c
